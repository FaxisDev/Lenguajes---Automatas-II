__CONFIG _CP_OFF & _WDT_OFF & _PWRTE_ON & _XT_OSC
LIST P=16F84A
INCLUDE <P16F84A.INC>


ORG 0
BSF STATUS, RP0
MOVLW b'00000110'
MOVWF TRISA
CLRF TRISB

BCF STATUS, RP0

PRINCIPAL

MOVLW b'11111111'
MOVWF PORTB

PRIMERA
BTFSS PORTA, 1 ;Es el Pin 18
GOTO AC1
GOTO SEGUNDA

SEGUNDA
BTFSC PORTA, 2 ;Es el Pin 1
GOTO AC2
GOTO PRIMERA


AC1
MOVLW b'00001111'
MOVWF PORTB
GOTO SEGUNDA

AC2 
MOVLW b'11110000'
MOVWF PORTB
GOTO PRIMERA

END